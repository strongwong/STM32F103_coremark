# IAR project F103coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_IAR
  ICCARM.CCIncludePath2: ..\..\App\inc; ..\..\Board\inc; ..\..\Chip\CMSIS; ..\..\Chip\Hal_lib\inc; ..\..\Chip\Startup\inc; ..\..\coremark; ..\RTE\_CoreMark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: F103coremark.srec
  ILINK.IlinkOutputFile: F103coremark.out
  ILINK.IlinkIcfFile: stm32f103x8_coremark.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group App
    ../../App/: delay.c
  group Cormark
    ../../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group Hal_lib
    ../../Chip/Hal_lib/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../../Chip/Startup/iar/: startup_stm32f10x_md.s
    ../../Chip/Startup/: system_stm32f10x.c
